## src/modules/remaining_range/Kconfig
```kconfig
menuconfig MODULES_REMAINING_RANGE
	bool "remaining_range"
	default n
	---help---
		Enable support for remaining_range
```
